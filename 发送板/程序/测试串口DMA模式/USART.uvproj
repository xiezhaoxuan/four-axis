# Keil uVision project USART.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F102C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: USART
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\DRIVER;.\LIBRARY\Libraries\STM32F10x_StdPeriph_Driver\inc;.\LIBRARY\Libraries\CMSIS\CM3\CoreSupport;.\LIBRARY\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\USER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group STARTUP
    ./LIBRARY/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group USER
    ./USER/: main.c stm32f10x_it.c
  group LIBRARY
    ./LIBRARY/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c
  group DRIVER
    ./DRIVER/: led.c systick.c usart1.c
  group CMSIS
    ./LIBRARY/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./LIBRARY/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
