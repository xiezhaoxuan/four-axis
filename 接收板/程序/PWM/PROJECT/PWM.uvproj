# Keil uVision project PWM.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103T8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: PWM
  c flags: Optim=1
  c include: ..\APP;..\CMSIS;..\DRIVER;..\LIBRARY\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../APP/: main.c
  group DRIVER
    ../DRIVER/: stm32f10x_it.c MOTOR.c led.c systemtick.c
  group LIBRARY
    ../LIBRARY/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c
  group CMSIS
    ../CMSIS/: core_cm3.c startup_stm32f10x_md.s system_stm32f10x.c
